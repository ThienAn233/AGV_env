Commit message: modify readme file and fix

File: urdf/AGV.urdf (robot description, URDF)
Before this commit: robot AGV, 5 links, 4 joints
Links:
- link base_link: mass 1 -> 2
